# Keil uVision project STM32.uvprojx, settings and files
target STM32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\stm32_lib\inc;..\system\config;..\system;..\user;..\driver;..\device
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./: main.c stm32f10x_it.c system_stm32f10x.c include.h
  group system
    ../system/: system.c core_cm3.c startup_stm32f10x_hd.s
  group lib
    ../stm32_lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_dac.c stm32f10x_tim.c
  group driver
    ../driver/: gpio.c uart.c time.c uart2.c
  group device
    ../device/: ec200.c
  group readme
    ../: README.TXT
